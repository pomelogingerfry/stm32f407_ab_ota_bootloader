LR_IROM1 0x08080000 0x00040000  {
  ER_IROM1 0x08080000 0x00040000  {
    *.o (RESET, +First)
    *(InRoot$$Sections)
    .ANY (+RO)
  }
  RW_IRAM1 0x20000000 0x00030000  {
    .ANY (+RW +ZI)
  }
}
