# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (6220000::V6.22::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: bootloader +hex
  AfterMake: fromelf --bin --output ..\..\firmware\bootloader\bootloader.bin .\bootloader\bootloader.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,BOOTLOADER
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\FLASH_DRIVER;..\BOOT_OTA;..\..\app_a;..\..\app_b;..\..\falsh_parttion;..\..\firmware;..\..\hardfault_capture;..\TASK_MONITOR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: ..\bootloader.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group FlashPartition
    ../../falsh_parttion/: flash_partition.h
  group Jump
    ../JUMP/: boot_jump.c boot_jump.h
  group FlashDriver
    ../FLASH_DRIVER/: flash_driver.c flash_driver.h
  group HardFaultCapture
    ../../hardfault_capture/: hardfault_capture.c hardfault_capture.h
  group BootOta
    ../BOOT_OTA/: error_code.c error_code.h ota_protocol.c ota_protocol.h boot_flag.c boot_flag.h state_machine.c state_machine.h ring_buffer.c ring_buffer.h
  group TaskMonitor
    ../TASK_MONITOR/: task_monitor_boot.c task_monitor_boot.h
software components: CMSIS:CORE 6.1.0
